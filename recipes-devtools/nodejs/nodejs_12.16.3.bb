require nodejs_12.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=126890df35936bbffe9fa00c90ad4870"

SRC_URI[src.md5sum] = "8977bcdb78c5ea63544e57115aeff8d8"
SRC_URI[src.sha256sum] = "4694056576b6c48a70ad401cf061181eafbc3cbf5070907cdba4e6de1be567a5"


